# Keil uVision project flash_program.uvproj, settings and files
target nrf_proto (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: flash_program
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL
  c include: .\inc;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\CMSIS\Core\CM3;.\src\nrf_proto
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./src/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c serial_communication.c data_handle.c led.c
  group USB-FS-Device_Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_gpio.c
  group RVMDK
    ./Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group NRF_PROTO
    ./src/nrf_proto/: nrf_hal.c nrf_help.c nrf_interface.c nrf_interrupt.c nrf_memory.c nrf_phy.c nrf_timer.c nrf_store_interface.c
target dfu_nrf_proto (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: flash_program +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL,DFU_NPROTO
  c include: as above
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x5000
